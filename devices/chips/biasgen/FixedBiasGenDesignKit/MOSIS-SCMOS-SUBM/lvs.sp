$ use to lvs schematics by including a spice option that scales lambda to microns

.options scale=0.2u
.include biasgen-lvs.sp
