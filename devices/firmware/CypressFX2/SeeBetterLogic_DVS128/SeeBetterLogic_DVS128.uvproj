# Keil uVision project SeeBetterLogic_DVS128.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: SeeBetterLogic_DVS128 +hex
  AfterMake: utils\makeHexBixCopyToJava.cmd
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: dscr.a51 fw.c main.c
    C:/Cypress/USB/CY3684_EZ-USB_FX2LP_DVK/1.0/Target/Lib/LP/: EZUSB.LIB USBJmpTb.OBJ
    C:/Cypress/USB/CY3684_EZ-USB_FX2LP_DVK/1.0/Target/Inc/: syncdly.h Fx2.h fx2regs.h
    ./xsvf_player/: ports.c micro.c lenval.c
