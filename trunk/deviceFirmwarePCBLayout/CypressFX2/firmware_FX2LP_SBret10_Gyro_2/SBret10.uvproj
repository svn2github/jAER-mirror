# Keil uVision project SBret10.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0xE000-0xE3FF) CLOCK(48000000) MODDP2
  output: SBret10 +hex
  AfterMake: "makeHexBixCopyToJava.cmd"
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: fw.c dscr.a51 biasgen.h spiwritebyte.a51 main.c ports.h opcode.h ISR_Timer2_JumpVector.a51
    C:/Cypress/USB/Target/Lib/LP/: EZUSB.LIB USBJmpTb.OBJ
    C:/Cypress/USB/Target/Inc/: syncdly.h lp.h lpregs.h lpregs.inc
    C:/Keil/C51/INC/Cypress/: Fx2.h fx2regs.h
